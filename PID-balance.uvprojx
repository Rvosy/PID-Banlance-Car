# Keil uVision project PID-balance.uvprojx, settings and files
target PID-balance (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PID-balance
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .eide\deps;Hardware;Library;Start;System;User;Hardware\MPU6050DMP
  asm define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group HARDWARE
    Hardware/: Encoder.c exti.c Motor.c MyI2C.c oled.c
  group HARDWARE/MPU6050DMP
    Hardware/MPU6050DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c MPU6050.c MPU6050_I2C.c
  group LIBRARY
    Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group START
    Start/: core_cm3.c startup_stm32f10x_cl.s startup_stm32f10x_md.s system_stm32f10x.c
  group SYSTEM
    System/: Delay.c PID.c sys.c usart.c
  group USER
    User/: KF.c main.c stm32f10x_it.c
